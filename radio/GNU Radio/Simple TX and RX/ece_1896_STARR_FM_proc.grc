options:
  parameters:
    generate_options: qt_gui
    id: ece_1896_STARR_FM_
    output_language: python
    title: ECE 1896 STARR FM RX
  states: {}

blocks:
- name: RF_samp_rate
  id: variable
  parameters:
    value: '480000'
  states: {}
- name: audio_samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: audio_volume_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '2'
    value: '0.1'
  states: {}
- name: carrier_freq
  id: variable
  parameters:
    value: int(147.540e6)
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '64'
    value: '40'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: audio_samp_rate
    max_dev: 5e3
    quad_rate: RF_samp_rate
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_samp_rate
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_volume_gain
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: /home/adam-nichols/Documents/Pitt/ECE 1896/DemodulatedVoiceTestMessage.wav
    format: FORMAT_WAV
    samp_rate: audio_samp_rate
  states: {}
- name: blocks_wavfile_sink_0_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: /home/adam-nichols/Documents/Pitt/ECE 1896/RFRealTestMessage.wav
    format: FORMAT_WAV
    samp_rate: audio_samp_rate
  states: {}
- name: blocks_wavfile_sink_0_0_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: /home/adam-nichols/Documents/Pitt/ECE 1896/RFImagTestMessage.wav
    format: FORMAT_WAV
    samp_rate: audio_samp_rate
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: carrier_freq
    gain1: '''manual'''
    manual_gain1: rf_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: RF_samp_rate
    type: fc32
    uri: ip:192.168.2.20
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: int(30e3)
    decim: '1'
    gain: '1'
    samp_rate: RF_samp_rate
    type: fir_filter_ccf
    width: int(10e3)
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: audio_samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Audio Message"'
    type: float
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: RF_samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"RF Downconverted Signal"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: RF_samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"RF Downconverted Signal After LP"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Audio Message"'
    size: '1024'
    srate: audio_samp_rate
    type: float
  states: {}

connections:
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_float_0, '0', blocks_wavfile_sink_0_0, '0']
- [blocks_complex_to_float_0, '1', blocks_wavfile_sink_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [iio_pluto_source_0, '0', blocks_complex_to_float_0, '0']
- [iio_pluto_source_0, '0', low_pass_filter_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_1, '0']
- [low_pass_filter_0, '0', analog_nbfm_rx_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
