options:
  parameters:
    author: adam-nichols
    generate_options: qt_gui
    id: ece_1896_STARR_FM_TX
    output_language: python
    title: ece_1896_STARR_FM_TX
  states: {}

blocks:
- name: RF_samp_rate
  id: variable
  parameters:
    value: '480000'
  states: {}
- name: atten
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '89.7'
    value: '10'
  states: {}
- name: audio_samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: carrier_freq
  id: variable
  parameters:
    value: int(147.540e6)
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: audio_samp_rate
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: RF_samp_rate
    tau: '75e-6'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/adam-nichols/Documents/Pitt/ECE 1896/ECE1472 Lab1 speech files/Fessenden_long_clip_fs48000_mono.wav
    repeat: 'True'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: atten
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: carrier_freq
    samplerate: RF_samp_rate
    type: fc32
    uri: ip:192.168.2.20
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Audio"'
    size: '1024'
    srate: audio_samp_rate
    type: float
  states: {}

connections:
- [analog_nbfm_tx_0, '0', iio_pluto_sink_0, '0']
- [blocks_wavfile_source_0, '0', analog_nbfm_tx_0, '0']
- [blocks_wavfile_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
