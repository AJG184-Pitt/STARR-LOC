options:
  parameters:
    author: Steve Jacobs
    generate_options: qt_gui
    id: noaa_weather_spj_v1
    output_language: python
    title: NOAA Weather Radio
  states: {}

blocks:
- name: LPF_cutoff
  id: variable
  parameters:
    value: int(50e3)
  states: {}
- name: LPF_decimation
  id: variable
  parameters:
    value: '10'
  states: {}
- name: LPF_samp_rate
  id: variable
  parameters:
    value: int(RF_samp_rate/LPF_decimation)
  states: {}
- name: LPF_transition
  id: variable
  parameters:
    value: int(500e3)
  states: {}
- name: RF_samp_rate
  id: variable
  parameters:
    value: int(2e6)
  states: {}
- name: audio_gain
  id: variable_qtgui_range
  parameters:
    min_len: '100'
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.02'
  states: {}
- name: audio_samp_rate
  id: variable
  parameters:
    value: int(16e3)
  states: {}
- name: carrier_freq
  id: variable_qtgui_range
  parameters:
    min_len: '100'
    start: 161e6
    step: 25e3
    stop: 164e6
    value: 162.55e6
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: LPF_samp_rate
    max_dev: 5e3
    quad_rate: LPF_samp_rate
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '16000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: int(carrier_freq)
    gain1: '''manual'''
    manual_gain1: '52'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: RF_samp_rate
    type: fc32
    uri: 192.168.2.4
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: LPF_cutoff
    decim: LPF_decimation
    gain: '1'
    samp_rate: RF_samp_rate
    type: fir_filter_ccf
    width: LPF_transition
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: int(RF_samp_rate)
    ctrlpanel: 'True'
    fc: carrier_freq
    fftsize: '1024'
    grid: 'True'
    label1: '|S(f)|'
    name: '"RX Spectrum"'
    type: complex
    update_time: '0.05'
    wintype: window.WIN_BLACKMAN
    ymax: '0'
    ymin: '-80'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: int(LPF_samp_rate)
    ctrlpanel: 'True'
    fc: carrier_freq
    fftsize: '1024'
    grid: 'True'
    label1: '|X(f)|'
    name: '"LPF Spectrum"'
    type: complex
    update_time: '0.05'
    wintype: window.WIN_BLACKMAN
    ymax: '0'
    ymin: '-80'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: int(audio_samp_rate)
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    label1: M(f)
    name: '"Audio Spectrum"'
    type: float
    update_time: '0.05'
    wintype: window.WIN_BLACKMAN
    ymax: '0'
    ymin: '-80'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    entags: 'False'
    grid: 'True'
    label1: Real{s(t)}
    label2: Imags(t)}
    name: '"RX Signal"'
    size: '1024'
    srate: RF_samp_rate
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    ymax: '2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    entags: 'False'
    grid: 'True'
    label1: Real{x(t)}
    label2: Imag{x(t)}
    name: '"LPF Signal"'
    size: '1024'
    srate: LPF_samp_rate
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
    ymax: '2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    entags: 'False'
    grid: 'True'
    label1: m(t)
    name: '"Audio Signal"'
    size: '1024'
    srate: audio_samp_rate
    type: float
    ymax: '2'
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(LPF_samp_rate/8e3)
    interp: int(audio_samp_rate/8e3)
    type: fff
  states: {}

connections:
- [analog_nbfm_rx_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [iio_pluto_source_0, '0', low_pass_filter_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0_0_0_0, '0']
- [iio_pluto_source_0, '0', qtgui_time_sink_x_0, '0']
- [low_pass_filter_0, '0', analog_nbfm_rx_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0_0_0_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_freq_sink_x_0_0_0_0_0_0, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_time_sink_x_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
