options:
  parameters:
    author: adam-nichols
    generate_options: qt_gui
    id: ece_1896_nichols_voice_detection_wbfm
    output_language: python
    title: ECE 1896 WBFM Auto Squelch
  states: {}

blocks:
- name: RF_samp_rate
  id: variable
  parameters:
    value: '480000'
  states: {}
- name: audio_samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: carrier_freq
  id: variable_qtgui_range
  parameters:
    start: int(86.1e6)
    step: int(200e3)
    stop: int(108.1e6)
    value: int(92.1e6)
  states: {}
- name: int_length
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    start: '10'
    step: '1'
    stop: '64'
    value: '40'
  states: {}
- name: thresh
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '.01'
    stop: '1'
    value: '.5'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '256000'
    rate: '1e-4'
    reference: '.5'
    type: complex
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: int(RF_samp_rate/audio_samp_rate)
    audio_pass: '15000'
    audio_stop: '16000'
    chan_rate: RF_samp_rate
    deviation: '75000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_samp_rate
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: complex
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: int_length
    type: complex
  states: {}
- name: blocks_integrate_xx_0_0
  id: blocks_integrate_xx
  parameters:
    decim: int_length
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: thresh
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_2
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '800'
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: 2*3.1415/100
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      import wave
      import os
      import time
      from gnuradio import gr
      from pydub import AudioSegment
      from pydub.generators import Sine

      class save_mp3_on_trigger(gr.sync_block):
          """
          Embedded Python Block that records float samples into an MP3 file when a trigger signal is detected.
          Input 1 is the float audio stream. Input 2 is the float trigger signal.
          """
          def __init__(self, sample_rate=48000):
              gr.sync_block.__init__(
                  self,
                  name="save_mp3_on_trigger",
                  in_sig=[np.float32, np.float32],  # Float samples and trigger signal
                  out_sig=None
              )
              self.sample_rate = sample_rate
              self.recording = False
              self.audio_buffer = []
              self.output_dir = "recordings"
              if not os.path.exists(self.output_dir):
                  os.makedirs(self.output_dir)

          def start_new_recording(self):
              timestamp = time.strftime("%Y-%m-%d_%H-%M-%S")
              self.filename = os.path.join(self.output_dir, f"recording_{timestamp}.wav")
              self.audio_buffer = []
              print(f"Recording started: {self.filename}")

          def stop_and_save(self):
              if self.audio_buffer:
                  temp_wav = self.filename
                  with wave.open(temp_wav, 'w') as wf:
                      wf.setnchannels(1)
                      wf.setsampwidth(2)
                      wf.setframerate(self.sample_rate)
                      wf.writeframes(np.array(self.audio_buffer, dtype=np.int16).tobytes())
                  
                  audio = AudioSegment.from_wav(temp_wav)
                  mp3_filename = temp_wav.replace(".wav", ".mp3")
                  audio.export(mp3_filename, format="mp3")
                  os.remove(temp_wav)  # Delete temporary WAV file
                  print(f"Saved recording: {mp3_filename}")
              self.audio_buffer = []

          def work(self, input_items, output_items):
              samples = input_items[0]
              trigger = input_items[1]
              
              for i in range(len(samples)):
                  if trigger[i] == 1:
                      if not self.recording:
                          self.recording = True
                          self.start_new_recording()
                      self.audio_buffer.append(int(samples[i] * 32767))
                  elif self.recording:
                      self.stop_and_save()
                      self.recording = False

              return len(samples)
    sample_rate: '48000'
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      import wave
      import os
      import time
      from gnuradio import gr
      from pydub import AudioSegment
      from pydub.generators import Sine

      class save_mp3_on_trigger(gr.sync_block):
          """
          Embedded Python Block that records float samples into an MP3 file when a trigger signal is detected.
          Input 1 is the float audio stream. Input 2 is the float trigger signal.
          """
          def __init__(self, sample_rate=48000):
              gr.sync_block.__init__(
                  self,
                  name="save_mp3_on_trigger",
                  in_sig=[np.float32, np.float32],  # Float samples and trigger signal
                  out_sig=None
              )
              self.sample_rate = sample_rate
              self.recording = False
              self.audio_buffer = []
              self.output_dir = "recordings"
              if not os.path.exists(self.output_dir):
                  os.makedirs(self.output_dir)

          def start_new_recording(self):
              timestamp = time.strftime("%Y-%m-%d_%H-%M-%S")
              self.filename = os.path.join(self.output_dir, f"recording_{timestamp}.wav")
              self.audio_buffer = []
              print(f"Recording started: {self.filename}")

          def stop_and_save(self):
              if self.audio_buffer:
                  temp_wav = self.filename
                  with wave.open(temp_wav, 'w') as wf:
                      wf.setnchannels(1)
                      wf.setsampwidth(2)
                      wf.setframerate(self.sample_rate)
                      wf.writeframes(np.array(self.audio_buffer, dtype=np.int16).tobytes())
                  
                  audio = AudioSegment.from_wav(temp_wav)
                  mp3_filename = temp_wav.replace(".wav", ".mp3")
                  audio.export(mp3_filename, format="mp3")
                  os.remove(temp_wav)  # Delete temporary WAV file
                  print(f"Saved recording: {mp3_filename}")
              self.audio_buffer = []

          def work(self, input_items, output_items):
              samples = input_items[0]
              trigger = input_items[1]
              
              for i in range(len(samples)):
                  if trigger[i] == 1:
                      if not self.recording:
                          self.recording = True
                          self.start_new_recording()
                      self.audio_buffer.append(int(samples[i] * 32767))
                  elif self.recording:
                      self.stop_and_save()
                      self.recording = False

              return len(samples)
    sample_rate: '48000'
  states: {state: disabled}
- name: epy_block_0_1
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nimport wave\nimport os\nimport time\nfrom gnuradio import gr\nfrom pydub import AudioSegment\n\nclass save_mp3_on_trigger(gr.sync_block):\n    \"\"\"\n    Embedded Python Block that records float samples into an MP3 file when a trigger signal is detected.\n    Input 1 is the float audio stream. Input 2 is the float trigger signal.\n    \"\"\"\n    def __init__(self, sample_rate=48000):\n        gr.sync_block.__init__(\n            self,\n            name=\"save_mp3_on_trigger\",\n            in_sig=[np.float32, np.float32],  # Float samples and trigger signal\n            out_sig=None\n        )\n        self.sample_rate = sample_rate\n        self.recording = False\n        self.audio_buffer = []\n        self.output_dir = \"recordings\"\n        self.start_time = None\n        if not os.path.exists(self.output_dir):\n            os.makedirs(self.output_dir)\n        self.filename = None\n\n    def start_new_recording(self):\n        timestamp = time.strftime(\"%Y-%m-%d_%H-%M-%S\")\n        self.filename = os.path.join(self.output_dir, f\"recording_{timestamp}.wav\")\n        self.audio_buffer = []\n        self.start_time = time.time()\n        print(f\"Recording started: {self.filename}\")\n\n    def stop_and_save(self):\n        if len(self.audio_buffer) > 0 and self.start_time and (time.time() - self.start_time) >= 1:\n            temp_wav = self.filename\n            with wave.open(temp_wav, 'wb') as wf:\n                wf.setnchannels(1)\n                wf.setsampwidth(2)\n                wf.setframerate(self.sample_rate)\n                wf.writeframes(np.array(self.audio_buffer, dtype=np.int16).tobytes())\n            \n            audio = AudioSegment.from_wav(temp_wav)\n            mp3_filename = temp_wav.replace(\".wav\", \".mp3\")\n            audio.export(mp3_filename, format=\"mp3\")\n            os.remove(temp_wav)  # Delete temporary WAV file\n            print(f\"Saved recording: {mp3_filename}\")\n        else:\n            print(\"Recording discarded: Less than 1 second\")\n        \n        self.audio_buffer = []\n        self.start_time = None\n\n    def work(self, input_items, output_items):\n        samples = input_items[0]\n        trigger = input_items[1]\n        \n        for i in range(len(samples)):\n            if trigger[i] == 1:\n                if not self.recording:\n                    self.recording = True\n                    self.start_new_recording()\n                self.audio_buffer.append(int(samples[i] * 32767))\n            elif self.recording:\n                # Ensure at least 1 second of recording before stopping\n                if self.start_time and (time.time() - self.start_time) >= 1:\n                    self.stop_and_save()\n                    self.recording = False\n                else:\n                    print(\"Recording discarded: Less than 1 second\")\n                    self.audio_buffer = []\n                    self.recording = False\n\n        return len(samples)\n\n"
    sample_rate: '48000'
  states: {state: disabled}
- name: epy_block_0_2
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nimport wave\nimport os\nimport time\nfrom gnuradio import gr\nfrom pydub import AudioSegment\n\nclass save_mp3_on_trigger(gr.sync_block):\n    \"\"\"\n    Embedded Python Block that records float samples into an MP3 file when a trigger signal is detected.\n    Input 1 is the float audio stream. Input 2 is the float trigger signal.\n    \"\"\"\n    def __init__(self, sample_rate=48000):\n        gr.sync_block.__init__(\n            self,\n            name=\"save_mp3_on_trigger\",\n            in_sig=[np.float32, np.float32],  # Float samples and trigger signal\n            out_sig=None\n        )\n        self.sample_rate = sample_rate\n        self.recording = False\n        self.audio_buffer = []\n        self.output_dir = \"recordings\"\n        self.start_time = None\n        if not os.path.exists(self.output_dir):\n            os.makedirs(self.output_dir)\n        self.filename = None\n        self.min_samples = self.sample_rate  # Minimum 1 second worth of samples\n\n    def start_new_recording(self):\n        timestamp = time.strftime(\"%Y-%m-%d_%H-%M-%S\")\n        self.filename = os.path.join(self.output_dir, f\"recording_{timestamp}.wav\")\n        self.audio_buffer = []\n        self.start_time = time.time()\n        print(f\"Recording started: {self.filename}\")\n\n    def stop_and_save(self):\n        if len(self.audio_buffer) >= self.min_samples:\n            with wave.open(self.filename, 'wb') as wf:\n                wf.setnchannels(1)\n                wf.setsampwidth(2)\n                wf.setframerate(self.sample_rate)\n                wf.writeframes(np.array(self.audio_buffer, dtype=np.int16).tobytes())\n            \n            audio = AudioSegment.from_wav(self.filename)\n            mp3_filename = self.filename.replace(\".wav\", \".mp3\")\n            audio.export(mp3_filename, format=\"mp3\")\n            os.remove(self.filename)  # Delete temporary WAV file\n            print(f\"Saved recording: {mp3_filename}\")\n        else:\n            print(\"Recording discarded: Less than 1 second\")\n        \n        self.audio_buffer = []\n        self.start_time = None\n        self.recording = False\n\n    def work(self, input_items, output_items):\n        samples = input_items[0]\n        trigger = input_items[1]\n        \n        for i in range(len(samples)):\n            if trigger[i] == 1:\n                if not self.recording:\n                    self.recording = True\n                    self.start_new_recording()\n                self.audio_buffer.append(int(samples[i] * 32767))\n            elif self.recording:\n                # Stop only if we have at least 1 second of audio\n                if len(self.audio_buffer) >= self.min_samples:\n                    self.stop_and_save()\n                else:\n                    print(\"Recording discarded: Less than 1 second\")\n                    self.audio_buffer = []\n                    self.recording = False\n\n        return len(samples)\n\n"
    sample_rate: '48000'
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: carrier_freq
    gain1: '''manual'''
    manual_gain1: rf_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: RF_samp_rate
    type: fc32
    uri: ip:192.168.2.4
  states: {}
- name: qtgui_auto_correlator_sink_0
  id: qtgui_auto_correlator_sink
  parameters:
    fac_decimation: '10'
    fac_size: '512'
    sampRate: RF_samp_rate
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    entags: 'False'
    name: '"Raw Baseband Message"'
    size: '1024'
    srate: RF_samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    size: '1024'
    srate: audio_samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    name: '"Demodulated FM"'
    size: '1024'
    srate: audio_samp_rate
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: autocorr_diff
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: WBFM_freq_corrected
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: WBFM_freq_corrected
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: autocorr_diff
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: WBFM_freq_corrected
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_conjugate_cc_0, '0']
- [analog_agc_xx_0, '0', blocks_conjugate_cc_0_0, '0']
- [analog_agc_xx_0, '0', blocks_delay_0, '0']
- [analog_agc_xx_0, '0', blocks_multiply_xx_0, '1']
- [analog_agc_xx_0, '0', qtgui_auto_correlator_sink_0, '0']
- [analog_agc_xx_0, '0', qtgui_time_sink_x_0, '0']
- [analog_fm_demod_cf_0, '0', blocks_multiply_xx_2, '0']
- [blocks_char_to_float_0, '0', blocks_repeat_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_sub_xx_0, '1']
- [blocks_complex_to_mag_0_0, '0', blocks_sub_xx_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '0']
- [blocks_conjugate_cc_0_0, '0', blocks_multiply_xx_1, '0']
- [blocks_delay_0, '0', blocks_multiply_xx_1, '1']
- [blocks_integrate_xx_0, '0', blocks_complex_to_mag_0_0, '0']
- [blocks_integrate_xx_0_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_complex_to_mag_0, '0']
- [blocks_multiply_xx_0, '0', blocks_integrate_xx_0_0, '0']
- [blocks_multiply_xx_1, '0', blocks_integrate_xx_0, '0']
- [blocks_multiply_xx_2, '0', audio_sink_0, '0']
- [blocks_multiply_xx_2, '0', epy_block_0, '0']
- [blocks_multiply_xx_2, '0', qtgui_time_sink_x_2, '0']
- [blocks_repeat_0, '0', blocks_multiply_xx_2, '1']
- [blocks_repeat_0, '0', epy_block_0, '1']
- [blocks_repeat_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_sub_xx_0, '0', virtual_sink_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_char_to_float_0, '0']
- [digital_costas_loop_cc_0, '0', virtual_sink_1, '0']
- [iio_pluto_source_0, '0', digital_costas_loop_cc_0, '0']
- [virtual_source_0, '0', analog_fm_demod_cf_0, '0']
- [virtual_source_0_0, '0', digital_binary_slicer_fb_0, '0']
- [virtual_source_0_1, '0', analog_agc_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
