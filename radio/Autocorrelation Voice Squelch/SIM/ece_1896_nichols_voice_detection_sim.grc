options:
  parameters:
    author: adam-nichols
    generate_options: qt_gui
    id: ece_1896_nichols_voice_detection_sim
    output_language: python
    title: Voice Detection Simulation
  states: {}

blocks:
- name: audio_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '.01'
    stop: '5'
    value: '1'
  states: {}
- name: audio_samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: int_length
  id: variable
  parameters:
    value: '24000'
  states: {}
- name: noise_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '.01'
    stop: '5'
    value: '.1'
  states: {}
- name: thresh
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '.01'
    stop: '1'
    value: '.5'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '.5'
    type: float
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_samp_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: audio_samp_rate
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: int_length
    type: float
  states: {}
- name: blocks_integrate_xx_0_0
  id: blocks_integrate_xx
  parameters:
    decim: int_length
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: noise_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: thresh
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/adam-nichols/Documents/Pitt/ECE 1896/ECE1472 Lab1 speech files/Fessenden_long_clip_fs48000_mono.wav
    repeat: 'True'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: qtgui_auto_correlator_sink_0
  id: qtgui_auto_correlator_sink
  parameters:
    fac_decimation: '10'
    fac_size: '512'
    sampRate: audio_samp_rate
    title: '"Raw Audio Autocorrelation"'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: audio_samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    name: '"Raw Audio Spectrum"'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"Raw Audio Message"'
    size: '1024'
    srate: audio_samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: 3*int(audio_samp_rate/int_length)
    srate: audio_samp_rate/int_length
    type: float
  states: {}

connections:
- [analog_agc_xx_0, '0', audio_sink_0, '0']
- [analog_agc_xx_0, '0', blocks_delay_0, '0']
- [analog_agc_xx_0, '0', blocks_float_to_complex_0, '0']
- [analog_agc_xx_0, '0', blocks_float_to_complex_0, '1']
- [analog_agc_xx_0, '0', blocks_multiply_xx_0, '0']
- [analog_agc_xx_0, '0', blocks_multiply_xx_0, '1']
- [analog_agc_xx_0, '0', blocks_multiply_xx_1, '0']
- [analog_agc_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_agc_xx_0, '0', qtgui_time_sink_x_0, '0']
- [analog_noise_source_x_0, '0', blocks_multiply_const_vxx_0, '0']
- [audio_source_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_add_xx_0, '0', analog_agc_xx_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_delay_0, '0', blocks_multiply_xx_1, '1']
- [blocks_float_to_complex_0, '0', qtgui_auto_correlator_sink_0, '0']
- [blocks_integrate_xx_0, '0', blocks_sub_xx_0, '1']
- [blocks_integrate_xx_0_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_1, '0', blocks_sub_xx_0, '0']
- [blocks_multiply_xx_0, '0', blocks_integrate_xx_0_0, '0']
- [blocks_multiply_xx_1, '0', blocks_integrate_xx_0, '0']
- [blocks_sub_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_char_to_float_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
